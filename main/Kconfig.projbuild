## main/Kconfig.projbuild
```kconfig
menu "Project Configuration"
    config BLYNK_TOKEN
        string "Blynk Token"
        default ""
endmenu
```
